<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj; *.o</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc; *.md</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
    <nMigrate>0</nMigrate>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>AndroidF1</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>8000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>0</RunSim>
        <RunTarget>1</RunTarget>
        <RunAbUc>0</RunAbUc>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>C:\Users\Titanium\Documents\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>18</CpuCode>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>1</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRSysVw>1</sRSysVw>
        <tRSysVw>1</tRSysVw>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <bEvRecOn>1</bEvRecOn>
        <bSchkAxf>0</bSchkAxf>
        <bTchkAxf>0</bTchkAxf>
        <nTsel>6</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>STLink\ST-LINKIII-KEIL_SWO.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMRTXEVENTFLAGS</Key>
          <Name>-L70 -Z18 -C0 -M0 -T1</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(105=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 -FD20000000 -FC1000 -FN1 -FF0STM32F10x_128 -FS08000000 -FL020000 -FP0($$Device:STM32F103C8$Flash\STM32F10x_128.FLM))</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ST-LINKIII-KEIL_SWO</Key>
          <Name>-U360026001200004A5735534E -O206 -SF10000 -C0 -A0 -I0 -HNlocalhost -HP7184 -P1 -N00("ARM CoreSight SW-DP") -D00(1BA01477) -L00(0) -TO131090 -TC10000000 -TT10000000 -TP21 -TDS8004 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO15 -FD20000000 -FC800 -FN2 -FF0STM32F10x_128.FLM -FS08000000 -FL020000 -FP0($$Device:STM32F103C8$Flash\STM32F10x_128.FLM) -FF1STM32F10x_OPT.FLM -FS11FFFF800 -FL110 -FP1($$Device:STM32F103C8$Flash\STM32F10x_OPT.FLM)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint/>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>CDCRece</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>1</WinNumber>
          <ItemText>DR</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>1</WinNumber>
          <ItemText>((uint32_t)(0x1UL &lt;&lt; (5U))),0x10</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>1</WinNumber>
          <ItemText>Buf</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>1</WinNumber>
          <ItemText>RxBuffer</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>1</WinNumber>
          <ItemText>USBD_CDC_HandleTypeDef</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>1</WinNumber>
          <ItemText>hcdc</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>1</WinNumber>
          <ItemText>Buf</ItemText>
        </Ww>
        <Ww>
          <count>8</count>
          <WinNumber>1</WinNumber>
          <ItemText>rxBuffer,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>9</count>
          <WinNumber>1</WinNumber>
          <ItemText>Ftamplate_ID,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>10</count>
          <WinNumber>1</WinNumber>
          <ItemText>FTemplate_Len,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>11</count>
          <WinNumber>1</WinNumber>
          <ItemText>buffer</ItemText>
        </Ww>
        <Ww>
          <count>12</count>
          <WinNumber>1</WinNumber>
          <ItemText>Buffer</ItemText>
        </Ww>
        <Ww>
          <count>13</count>
          <WinNumber>1</WinNumber>
          <ItemText>wiegandLen,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>14</count>
          <WinNumber>1</WinNumber>
          <ItemText>wiegandRead</ItemText>
        </Ww>
        <Ww>
          <count>15</count>
          <WinNumber>1</WinNumber>
          <ItemText>RetValue</ItemText>
        </Ww>
        <Ww>
          <count>16</count>
          <WinNumber>1</WinNumber>
          <ItemText>rx</ItemText>
        </Ww>
        <Ww>
          <count>17</count>
          <WinNumber>1</WinNumber>
          <ItemText>wiegandRead</ItemText>
        </Ww>
        <Ww>
          <count>18</count>
          <WinNumber>1</WinNumber>
          <ItemText>buff</ItemText>
        </Ww>
        <Ww>
          <count>19</count>
          <WinNumber>1</WinNumber>
          <ItemText>ResBuff</ItemText>
        </Ww>
        <Ww>
          <count>20</count>
          <WinNumber>1</WinNumber>
          <ItemText>RetValue</ItemText>
        </Ww>
        <Ww>
          <count>21</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer[10]</ItemText>
        </Ww>
        <Ww>
          <count>22</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>23</count>
          <WinNumber>1</WinNumber>
          <ItemText>hr_old,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>24</count>
          <WinNumber>1</WinNumber>
          <ItemText>spo2_old,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>25</count>
          <WinNumber>1</WinNumber>
          <ItemText>ID</ItemText>
        </Ww>
        <Ww>
          <count>26</count>
          <WinNumber>1</WinNumber>
          <ItemText>max30102Flag</ItemText>
        </Ww>
        <Ww>
          <count>27</count>
          <WinNumber>1</WinNumber>
          <ItemText>hr_old,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>28</count>
          <WinNumber>1</WinNumber>
          <ItemText>IrBuffer,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>29</count>
          <WinNumber>1</WinNumber>
          <ItemText>Sp02Value,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>30</count>
          <WinNumber>1</WinNumber>
          <ItemText>Sp02IsValid</ItemText>
        </Ww>
        <Ww>
          <count>31</count>
          <WinNumber>1</WinNumber>
          <ItemText>BufferHead,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>32</count>
          <WinNumber>1</WinNumber>
          <ItemText>temp,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>33</count>
          <WinNumber>1</WinNumber>
          <ItemText>BufferTail,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>34</count>
          <WinNumber>1</WinNumber>
          <ItemText>buff,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>35</count>
          <WinNumber>1</WinNumber>
          <ItemText>avr</ItemText>
        </Ww>
        <Ww>
          <count>36</count>
          <WinNumber>1</WinNumber>
          <ItemText>Sp02Value,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>37</count>
          <WinNumber>1</WinNumber>
          <ItemText>HeartRate,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>38</count>
          <WinNumber>1</WinNumber>
          <ItemText>avrIr,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>39</count>
          <WinNumber>1</WinNumber>
          <ItemText>avrIrBuf,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>40</count>
          <WinNumber>1</WinNumber>
          <ItemText>cntt,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>41</count>
          <WinNumber>1</WinNumber>
          <ItemText>sample,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>42</count>
          <WinNumber>1</WinNumber>
          <ItemText>max30102,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>43</count>
          <WinNumber>1</WinNumber>
          <ItemText>spo2,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>44</count>
          <WinNumber>1</WinNumber>
          <ItemText>spo2valid</ItemText>
        </Ww>
        <Ww>
          <count>45</count>
          <WinNumber>1</WinNumber>
          <ItemText>hr,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>46</count>
          <WinNumber>1</WinNumber>
          <ItemText>hrvalid</ItemText>
        </Ww>
        <Ww>
          <count>47</count>
          <WinNumber>1</WinNumber>
          <ItemText>Ir,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>48</count>
          <WinNumber>1</WinNumber>
          <ItemText>cnt,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>49</count>
          <WinNumber>1</WinNumber>
          <ItemText>wr_ptr</ItemText>
        </Ww>
        <Ww>
          <count>50</count>
          <WinNumber>1</WinNumber>
          <ItemText>BUFFER_SIZE</ItemText>
        </Ww>
        <Ww>
          <count>51</count>
          <WinNumber>1</WinNumber>
          <ItemText>n_th1</ItemText>
        </Ww>
        <Ww>
          <count>52</count>
          <WinNumber>1</WinNumber>
          <ItemText>hrs,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>53</count>
          <WinNumber>1</WinNumber>
          <ItemText>spo2s,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>54</count>
          <WinNumber>1</WinNumber>
          <ItemText>status</ItemText>
        </Ww>
        <Ww>
          <count>55</count>
          <WinNumber>1</WinNumber>
          <ItemText>Idx,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>56</count>
          <WinNumber>1</WinNumber>
          <ItemText>Door1Release</ItemText>
        </Ww>
        <Ww>
          <count>57</count>
          <WinNumber>1</WinNumber>
          <ItemText>Door1Model</ItemText>
        </Ww>
        <Ww>
          <count>58</count>
          <WinNumber>1</WinNumber>
          <ItemText>BD1Ready</ItemText>
        </Ww>
        <Ww>
          <count>59</count>
          <WinNumber>1</WinNumber>
          <ItemText>BD2Ready</ItemText>
        </Ww>
        <Ww>
          <count>60</count>
          <WinNumber>1</WinNumber>
          <ItemText>Transactions,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>61</count>
          <WinNumber>1</WinNumber>
          <ItemText>OffTransactions,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>62</count>
          <WinNumber>1</WinNumber>
          <ItemText>Transactions2</ItemText>
        </Ww>
        <Ww>
          <count>63</count>
          <WinNumber>1</WinNumber>
          <ItemText>OffTransactions2</ItemText>
        </Ww>
        <Ww>
          <count>64</count>
          <WinNumber>1</WinNumber>
          <ItemText>DID</ItemText>
        </Ww>
        <Ww>
          <count>65</count>
          <WinNumber>1</WinNumber>
          <ItemText>__HAL_UART_GET_FLAG,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>66</count>
          <WinNumber>1</WinNumber>
          <ItemText>ID,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>67</count>
          <WinNumber>1</WinNumber>
          <ItemText>BD1ReadyTimer</ItemText>
        </Ww>
        <Ww>
          <count>68</count>
          <WinNumber>1</WinNumber>
          <ItemText>BD2ReadyTimer,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>69</count>
          <WinNumber>1</WinNumber>
          <ItemText>Door2CurNum</ItemText>
        </Ww>
        <Ww>
          <count>70</count>
          <WinNumber>1</WinNumber>
          <ItemText>LastDeviceRegistered,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>71</count>
          <WinNumber>1</WinNumber>
          <ItemText>Door2Statuses</ItemText>
        </Ww>
        <Ww>
          <count>72</count>
          <WinNumber>1</WinNumber>
          <ItemText>Door2Ver,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>73</count>
          <WinNumber>1</WinNumber>
          <ItemText>Door2Release,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>74</count>
          <WinNumber>1</WinNumber>
          <ItemText>Door2Model,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>75</count>
          <WinNumber>1</WinNumber>
          <ItemText>TicketBuffer</ItemText>
        </Ww>
        <Ww>
          <count>76</count>
          <WinNumber>1</WinNumber>
          <ItemText>LastPackets</ItemText>
        </Ww>
        <Ww>
          <count>77</count>
          <WinNumber>1</WinNumber>
          <ItemText>Door2CurNum,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>78</count>
          <WinNumber>1</WinNumber>
          <ItemText>DoorPrice,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>79</count>
          <WinNumber>1</WinNumber>
          <ItemText>OfflineStart,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>80</count>
          <WinNumber>1</WinNumber>
          <ItemText>CurPriceT</ItemText>
        </Ww>
        <Ww>
          <count>81</count>
          <WinNumber>1</WinNumber>
          <ItemText>ID,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>82</count>
          <WinNumber>1</WinNumber>
          <ItemText>Res</ItemText>
        </Ww>
        <Ww>
          <count>83</count>
          <WinNumber>1</WinNumber>
          <ItemText>CardID,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>84</count>
          <WinNumber>1</WinNumber>
          <ItemText>Status,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>85</count>
          <WinNumber>1</WinNumber>
          <ItemText>OffTransactions,0x10</ItemText>
        </Ww>
        <Ww>
          <count>86</count>
          <WinNumber>1</WinNumber>
          <ItemText>OffTransactions</ItemText>
        </Ww>
        <Ww>
          <count>87</count>
          <WinNumber>1</WinNumber>
          <ItemText>OffTrans,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>88</count>
          <WinNumber>1</WinNumber>
          <ItemText>Status</ItemText>
        </Ww>
        <Ww>
          <count>89</count>
          <WinNumber>1</WinNumber>
          <ItemText>Etebar,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>90</count>
          <WinNumber>1</WinNumber>
          <ItemText>Grouh,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>91</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>92</count>
          <WinNumber>1</WinNumber>
          <ItemText>Block</ItemText>
        </Ww>
        <Ww>
          <count>93</count>
          <WinNumber>1</WinNumber>
          <ItemText>price,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>94</count>
          <WinNumber>1</WinNumber>
          <ItemText>changeGpFlag,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>95</count>
          <WinNumber>1</WinNumber>
          <ItemText>Readed_BCC</ItemText>
        </Ww>
        <Ww>
          <count>96</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>97</count>
          <WinNumber>1</WinNumber>
          <ItemText>TicketBuffer</ItemText>
        </Ww>
        <Ww>
          <count>98</count>
          <WinNumber>1</WinNumber>
          <ItemText>add,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>99</count>
          <WinNumber>1</WinNumber>
          <ItemText>readMem</ItemText>
        </Ww>
        <Ww>
          <count>100</count>
          <WinNumber>1</WinNumber>
          <ItemText>memorySector,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>101</count>
          <WinNumber>1</WinNumber>
          <ItemText>readMem</ItemText>
        </Ww>
        <Ww>
          <count>102</count>
          <WinNumber>1</WinNumber>
          <ItemText>Transaction,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>103</count>
          <WinNumber>1</WinNumber>
          <ItemText>pd</ItemText>
        </Ww>
        <Ww>
          <count>104</count>
          <WinNumber>1</WinNumber>
          <ItemText>idx</ItemText>
        </Ww>
        <Ww>
          <count>105</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>106</count>
          <WinNumber>1</WinNumber>
          <ItemText>ti,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>107</count>
          <WinNumber>1</WinNumber>
          <ItemText>GroupOfCard</ItemText>
        </Ww>
        <Ww>
          <count>108</count>
          <WinNumber>1</WinNumber>
          <ItemText>RC522</ItemText>
        </Ww>
        <Ww>
          <count>109</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>110</count>
          <WinNumber>1</WinNumber>
          <ItemText>test</ItemText>
        </Ww>
        <Ww>
          <count>111</count>
          <WinNumber>1</WinNumber>
          <ItemText>CardID,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>112</count>
          <WinNumber>1</WinNumber>
          <ItemText>Value</ItemText>
        </Ww>
        <Ww>
          <count>113</count>
          <WinNumber>1</WinNumber>
          <ItemText>data</ItemText>
        </Ww>
        <Ww>
          <count>114</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf</ItemText>
        </Ww>
        <Ww>
          <count>115</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>116</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>117</count>
          <WinNumber>1</WinNumber>
          <ItemText>SubGroup,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>118</count>
          <WinNumber>1</WinNumber>
          <ItemText>sTime</ItemText>
        </Ww>
        <Ww>
          <count>119</count>
          <WinNumber>1</WinNumber>
          <ItemText>buff</ItemText>
        </Ww>
        <Ww>
          <count>120</count>
          <WinNumber>1</WinNumber>
          <ItemText>CS2</ItemText>
        </Ww>
        <Ww>
          <count>121</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>122</count>
          <WinNumber>1</WinNumber>
          <ItemText>pbuf</ItemText>
        </Ww>
        <Ww>
          <count>123</count>
          <WinNumber>1</WinNumber>
          <ItemText>Datestring</ItemText>
        </Ww>
        <Ww>
          <count>124</count>
          <WinNumber>1</WinNumber>
          <ItemText>Timestring</ItemText>
        </Ww>
        <Ww>
          <count>125</count>
          <WinNumber>1</WinNumber>
          <ItemText>my_id,0x10</ItemText>
        </Ww>
        <Ww>
          <count>126</count>
          <WinNumber>1</WinNumber>
          <ItemText>heightBuf</ItemText>
        </Ww>
        <Ww>
          <count>127</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf</ItemText>
        </Ww>
        <Ww>
          <count>128</count>
          <WinNumber>1</WinNumber>
          <ItemText>SubGroup</ItemText>
        </Ww>
        <Ww>
          <count>129</count>
          <WinNumber>1</WinNumber>
          <ItemText>HNPayment</ItemText>
        </Ww>
        <Ww>
          <count>130</count>
          <WinNumber>1</WinNumber>
          <ItemText>Etebar</ItemText>
        </Ww>
        <Ww>
          <count>131</count>
          <WinNumber>1</WinNumber>
          <ItemText>BCC,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>132</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer,0x10</ItemText>
        </Ww>
        <Ww>
          <count>133</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer,0x10</ItemText>
        </Ww>
        <Ww>
          <count>134</count>
          <WinNumber>1</WinNumber>
          <ItemText>paket,0x10</ItemText>
        </Ww>
        <Ww>
          <count>135</count>
          <WinNumber>1</WinNumber>
          <ItemText>waitToReadUHF1</ItemText>
        </Ww>
        <Ww>
          <count>136</count>
          <WinNumber>1</WinNumber>
          <ItemText>BCCC</ItemText>
        </Ww>
        <Ww>
          <count>137</count>
          <WinNumber>1</WinNumber>
          <ItemText>tickForUHF1,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>138</count>
          <WinNumber>1</WinNumber>
          <ItemText>GroupOfCard,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>139</count>
          <WinNumber>1</WinNumber>
          <ItemText>learncode,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>140</count>
          <WinNumber>1</WinNumber>
          <ItemText>valid</ItemText>
        </Ww>
        <Ww>
          <count>141</count>
          <WinNumber>1</WinNumber>
          <ItemText>press</ItemText>
        </Ww>
        <Ww>
          <count>142</count>
          <WinNumber>1</WinNumber>
          <ItemText>Tmp</ItemText>
        </Ww>
        <Ww>
          <count>143</count>
          <WinNumber>1</WinNumber>
          <ItemText>bufer</ItemText>
        </Ww>
        <Ww>
          <count>144</count>
          <WinNumber>1</WinNumber>
          <ItemText>DetectTruePacket</ItemText>
        </Ww>
        <Ww>
          <count>145</count>
          <WinNumber>1</WinNumber>
          <ItemText>Tmp</ItemText>
        </Ww>
        <Ww>
          <count>146</count>
          <WinNumber>1</WinNumber>
          <ItemText>tickLearnCode,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>147</count>
          <WinNumber>1</WinNumber>
          <ItemText>DetectTruePacket</ItemText>
        </Ww>
        <Ww>
          <count>148</count>
          <WinNumber>1</WinNumber>
          <ItemText>li</ItemText>
        </Ww>
        <Ww>
          <count>149</count>
          <WinNumber>1</WinNumber>
          <ItemText>uli</ItemText>
        </Ww>
        <Ww>
          <count>150</count>
          <WinNumber>1</WinNumber>
          <ItemText>ch</ItemText>
        </Ww>
        <Ww>
          <count>151</count>
          <WinNumber>1</WinNumber>
          <ItemText>uCredit,0x10</ItemText>
        </Ww>
        <Ww>
          <count>152</count>
          <WinNumber>1</WinNumber>
          <ItemText>li</ItemText>
        </Ww>
        <Ww>
          <count>153</count>
          <WinNumber>1</WinNumber>
          <ItemText>RFData</ItemText>
        </Ww>
        <Ww>
          <count>154</count>
          <WinNumber>1</WinNumber>
          <ItemText>RFDataLen</ItemText>
        </Ww>
        <Ww>
          <count>155</count>
          <WinNumber>1</WinNumber>
          <ItemText>Buffer</ItemText>
        </Ww>
        <Ww>
          <count>156</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>157</count>
          <WinNumber>1</WinNumber>
          <ItemText>CpuID</ItemText>
        </Ww>
        <Ww>
          <count>158</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf2</ItemText>
        </Ww>
        <Ww>
          <count>159</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf</ItemText>
        </Ww>
        <Ww>
          <count>160</count>
          <WinNumber>1</WinNumber>
          <ItemText>Credit,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>161</count>
          <WinNumber>1</WinNumber>
          <ItemText>Status,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>162</count>
          <WinNumber>1</WinNumber>
          <ItemText>test</ItemText>
        </Ww>
        <Ww>
          <count>163</count>
          <WinNumber>1</WinNumber>
          <ItemText>sum,0x10</ItemText>
        </Ww>
        <Ww>
          <count>164</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>165</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer2</ItemText>
        </Ww>
        <Ww>
          <count>166</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>167</count>
          <WinNumber>1</WinNumber>
          <ItemText>cnt,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>168</count>
          <WinNumber>1</WinNumber>
          <ItemText>HEtebar,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>169</count>
          <WinNumber>1</WinNumber>
          <ItemText>CardEtebar,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>170</count>
          <WinNumber>1</WinNumber>
          <ItemText>DisCount,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>171</count>
          <WinNumber>1</WinNumber>
          <ItemText>SubGroup,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>172</count>
          <WinNumber>1</WinNumber>
          <ItemText>sendTransactionFlag</ItemText>
        </Ww>
        <Ww>
          <count>173</count>
          <WinNumber>1</WinNumber>
          <ItemText>HEtebar</ItemText>
        </Ww>
        <Ww>
          <count>174</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf</ItemText>
        </Ww>
        <Ww>
          <count>175</count>
          <WinNumber>1</WinNumber>
          <ItemText>validHedieBuf</ItemText>
        </Ww>
        <Ww>
          <count>176</count>
          <WinNumber>1</WinNumber>
          <ItemText>DetectTruePacket</ItemText>
        </Ww>
        <Ww>
          <count>177</count>
          <WinNumber>1</WinNumber>
          <ItemText>learncode,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>178</count>
          <WinNumber>1</WinNumber>
          <ItemText>Tmp</ItemText>
        </Ww>
        <Ww>
          <count>179</count>
          <WinNumber>1</WinNumber>
          <ItemText>dly</ItemText>
        </Ww>
        <Ww>
          <count>180</count>
          <WinNumber>1</WinNumber>
          <ItemText>bitCnt,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>181</count>
          <WinNumber>1</WinNumber>
          <ItemText>enableIRQ</ItemText>
        </Ww>
        <Ww>
          <count>182</count>
          <WinNumber>1</WinNumber>
          <ItemText>tickLearnCode,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>183</count>
          <WinNumber>1</WinNumber>
          <ItemText>DetectTruePacket</ItemText>
        </Ww>
        <Ww>
          <count>184</count>
          <WinNumber>1</WinNumber>
          <ItemText>Credit</ItemText>
        </Ww>
        <Ww>
          <count>185</count>
          <WinNumber>1</WinNumber>
          <ItemText>Status</ItemText>
        </Ww>
        <Ww>
          <count>186</count>
          <WinNumber>1</WinNumber>
          <ItemText>str</ItemText>
        </Ww>
        <Ww>
          <count>187</count>
          <WinNumber>1</WinNumber>
          <ItemText>Config.MinEtebar,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>188</count>
          <WinNumber>1</WinNumber>
          <ItemText>PreEtebar</ItemText>
        </Ww>
        <Ww>
          <count>189</count>
          <WinNumber>1</WinNumber>
          <ItemText>TicketBuffer2</ItemText>
        </Ww>
        <Ww>
          <count>190</count>
          <WinNumber>1</WinNumber>
          <ItemText>pn532Version</ItemText>
        </Ww>
        <Ww>
          <count>191</count>
          <WinNumber>1</WinNumber>
          <ItemText>status</ItemText>
        </Ww>
        <Ww>
          <count>192</count>
          <WinNumber>1</WinNumber>
          <ItemText>status</ItemText>
        </Ww>
        <Ww>
          <count>193</count>
          <WinNumber>1</WinNumber>
          <ItemText>data</ItemText>
        </Ww>
        <Ww>
          <count>194</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf</ItemText>
        </Ww>
        <Ww>
          <count>195</count>
          <WinNumber>1</WinNumber>
          <ItemText>buff</ItemText>
        </Ww>
        <Ww>
          <count>196</count>
          <WinNumber>1</WinNumber>
          <ItemText>i2cReadStatus</ItemText>
        </Ww>
        <Ww>
          <count>197</count>
          <WinNumber>1</WinNumber>
          <ItemText>length,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>198</count>
          <WinNumber>1</WinNumber>
          <ItemText>preSernum[count]</ItemText>
        </Ww>
        <Ww>
          <count>199</count>
          <WinNumber>1</WinNumber>
          <ItemText>Credit</ItemText>
        </Ww>
        <Ww>
          <count>200</count>
          <WinNumber>1</WinNumber>
          <ItemText>Status,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>201</count>
          <WinNumber>1</WinNumber>
          <ItemText>UC,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>202</count>
          <WinNumber>1</WinNumber>
          <ItemText>idFR,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>203</count>
          <WinNumber>1</WinNumber>
          <ItemText>Status</ItemText>
        </Ww>
        <Ww>
          <count>204</count>
          <WinNumber>1</WinNumber>
          <ItemText>i2cStatus</ItemText>
        </Ww>
        <Ww>
          <count>205</count>
          <WinNumber>1</WinNumber>
          <ItemText>Status</ItemText>
        </Ww>
        <Ww>
          <count>206</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf</ItemText>
        </Ww>
        <Ww>
          <count>207</count>
          <WinNumber>1</WinNumber>
          <ItemText>sagTosh,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>208</count>
          <WinNumber>1</WinNumber>
          <ItemText>H,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>209</count>
          <WinNumber>1</WinNumber>
          <ItemText>loc,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>210</count>
          <WinNumber>1</WinNumber>
          <ItemText>Buffer</ItemText>
        </Ww>
        <Ww>
          <count>211</count>
          <WinNumber>1</WinNumber>
          <ItemText>Timeout</ItemText>
        </Ww>
        <Ww>
          <count>212</count>
          <WinNumber>1</WinNumber>
          <ItemText>max30102,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>213</count>
          <WinNumber>1</WinNumber>
          <ItemText>ResBuff</ItemText>
        </Ww>
        <Ww>
          <count>214</count>
          <WinNumber>1</WinNumber>
          <ItemText>GrouhPrice</ItemText>
        </Ww>
        <Ww>
          <count>215</count>
          <WinNumber>1</WinNumber>
          <ItemText>Jahan_logo</ItemText>
        </Ww>
        <Ww>
          <count>216</count>
          <WinNumber>1</WinNumber>
          <ItemText>Li,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>217</count>
          <WinNumber>1</WinNumber>
          <ItemText>z</ItemText>
        </Ww>
        <Ww>
          <count>218</count>
          <WinNumber>1</WinNumber>
          <ItemText>Len,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>219</count>
          <WinNumber>1</WinNumber>
          <ItemText>h0,0x10</ItemText>
        </Ww>
        <Ww>
          <count>220</count>
          <WinNumber>1</WinNumber>
          <ItemText>h1</ItemText>
        </Ww>
        <Ww>
          <count>221</count>
          <WinNumber>1</WinNumber>
          <ItemText>h2</ItemText>
        </Ww>
        <Ww>
          <count>222</count>
          <WinNumber>1</WinNumber>
          <ItemText>h3</ItemText>
        </Ww>
        <Ww>
          <count>223</count>
          <WinNumber>1</WinNumber>
          <ItemText>h4</ItemText>
        </Ww>
        <Ww>
          <count>224</count>
          <WinNumber>1</WinNumber>
          <ItemText>SHA</ItemText>
        </Ww>
        <Ww>
          <count>225</count>
          <WinNumber>1</WinNumber>
          <ItemText>NumCount</ItemText>
        </Ww>
        <Ww>
          <count>226</count>
          <WinNumber>1</WinNumber>
          <ItemText>PosBuff</ItemText>
        </Ww>
        <Ww>
          <count>227</count>
          <WinNumber>1</WinNumber>
          <ItemText>NumStr</ItemText>
        </Ww>
        <Ww>
          <count>228</count>
          <WinNumber>1</WinNumber>
          <ItemText>idx,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>229</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf</ItemText>
        </Ww>
        <Ww>
          <count>230</count>
          <WinNumber>1</WinNumber>
          <ItemText>i,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>231</count>
          <WinNumber>1</WinNumber>
          <ItemText>y</ItemText>
        </Ww>
        <Ww>
          <count>232</count>
          <WinNumber>1</WinNumber>
          <ItemText>m</ItemText>
        </Ww>
        <Ww>
          <count>233</count>
          <WinNumber>1</WinNumber>
          <ItemText>d</ItemText>
        </Ww>
        <Ww>
          <count>234</count>
          <WinNumber>1</WinNumber>
          <ItemText>h</ItemText>
        </Ww>
        <Ww>
          <count>235</count>
          <WinNumber>1</WinNumber>
          <ItemText>K</ItemText>
        </Ww>
        <Ww>
          <count>236</count>
          <WinNumber>1</WinNumber>
          <ItemText>BridgeOpenTime,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>237</count>
          <WinNumber>1</WinNumber>
          <ItemText>enterExit</ItemText>
        </Ww>
        <Ww>
          <count>238</count>
          <WinNumber>1</WinNumber>
          <ItemText>cmd</ItemText>
        </Ww>
        <Ww>
          <count>239</count>
          <WinNumber>1</WinNumber>
          <ItemText>checkSum,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>240</count>
          <WinNumber>1</WinNumber>
          <ItemText>RetValue</ItemText>
        </Ww>
        <Ww>
          <count>241</count>
          <WinNumber>1</WinNumber>
          <ItemText>buff</ItemText>
        </Ww>
        <Ww>
          <count>242</count>
          <WinNumber>1</WinNumber>
          <ItemText>a</ItemText>
        </Ww>
        <Ww>
          <count>243</count>
          <WinNumber>1</WinNumber>
          <ItemText>b</ItemText>
        </Ww>
        <Ww>
          <count>244</count>
          <WinNumber>1</WinNumber>
          <ItemText>c</ItemText>
        </Ww>
        <Ww>
          <count>245</count>
          <WinNumber>1</WinNumber>
          <ItemText>li</ItemText>
        </Ww>
        <Ww>
          <count>246</count>
          <WinNumber>1</WinNumber>
          <ItemText>timeeeee</ItemText>
        </Ww>
        <Ww>
          <count>247</count>
          <WinNumber>1</WinNumber>
          <ItemText>bitCnt,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>248</count>
          <WinNumber>1</WinNumber>
          <ItemText>LTime,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>249</count>
          <WinNumber>1</WinNumber>
          <ItemText>HTime,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>250</count>
          <WinNumber>1</WinNumber>
          <ItemText>bitCnt</ItemText>
        </Ww>
        <Ww>
          <count>251</count>
          <WinNumber>1</WinNumber>
          <ItemText>cntr,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>252</count>
          <WinNumber>1</WinNumber>
          <ItemText>bitCnt,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>253</count>
          <WinNumber>1</WinNumber>
          <ItemText>Tmp</ItemText>
        </Ww>
        <Ww>
          <count>254</count>
          <WinNumber>1</WinNumber>
          <ItemText>binaryNum</ItemText>
        </Ww>
        <Ww>
          <count>255</count>
          <WinNumber>1</WinNumber>
          <ItemText>num</ItemText>
        </Ww>
        <Ww>
          <count>256</count>
          <WinNumber>1</WinNumber>
          <ItemText>status</ItemText>
        </Ww>
        <Ww>
          <count>257</count>
          <WinNumber>1</WinNumber>
          <ItemText>data</ItemText>
        </Ww>
        <Ww>
          <count>258</count>
          <WinNumber>1</WinNumber>
          <ItemText>Ntagtest</ItemText>
        </Ww>
        <Ww>
          <count>259</count>
          <WinNumber>1</WinNumber>
          <ItemText>NtagRead</ItemText>
        </Ww>
        <Ww>
          <count>260</count>
          <WinNumber>1</WinNumber>
          <ItemText>NtagWrite</ItemText>
        </Ww>
        <Ww>
          <count>261</count>
          <WinNumber>1</WinNumber>
          <ItemText>res</ItemText>
        </Ww>
        <Ww>
          <count>262</count>
          <WinNumber>1</WinNumber>
          <ItemText>NtagReadZiroBlock</ItemText>
        </Ww>
        <Ww>
          <count>263</count>
          <WinNumber>1</WinNumber>
          <ItemText>price</ItemText>
        </Ww>
        <Ww>
          <count>264</count>
          <WinNumber>1</WinNumber>
          <ItemText>cash,0x10</ItemText>
        </Ww>
        <Ww>
          <count>265</count>
          <WinNumber>1</WinNumber>
          <ItemText>Config,0x10</ItemText>
        </Ww>
        <Ww>
          <count>266</count>
          <WinNumber>1</WinNumber>
          <ItemText>cashCheck</ItemText>
        </Ww>
        <Ww>
          <count>267</count>
          <WinNumber>1</WinNumber>
          <ItemText>test</ItemText>
        </Ww>
        <Ww>
          <count>268</count>
          <WinNumber>1</WinNumber>
          <ItemText>recv</ItemText>
        </Ww>
        <Ww>
          <count>269</count>
          <WinNumber>1</WinNumber>
          <ItemText>Temp</ItemText>
        </Ww>
        <Ww>
          <count>270</count>
          <WinNumber>1</WinNumber>
          <ItemText>secpos</ItemText>
        </Ww>
        <Ww>
          <count>271</count>
          <WinNumber>1</WinNumber>
          <ItemText>SPI_FLASH_BUF</ItemText>
        </Ww>
        <Ww>
          <count>272</count>
          <WinNumber>1</WinNumber>
          <ItemText>secoff</ItemText>
        </Ww>
        <Ww>
          <count>273</count>
          <WinNumber>1</WinNumber>
          <ItemText>recv</ItemText>
        </Ww>
        <Ww>
          <count>274</count>
          <WinNumber>1</WinNumber>
          <ItemText>i</ItemText>
        </Ww>
        <Ww>
          <count>275</count>
          <WinNumber>1</WinNumber>
          <ItemText>secremain,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>276</count>
          <WinNumber>1</WinNumber>
          <ItemText>pageremain,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>277</count>
          <WinNumber>1</WinNumber>
          <ItemText>NumByteToWrite</ItemText>
        </Ww>
        <Ww>
          <count>278</count>
          <WinNumber>1</WinNumber>
          <ItemText>memID,0x10</ItemText>
        </Ww>
        <Ww>
          <count>279</count>
          <WinNumber>1</WinNumber>
          <ItemText>fromAndroid</ItemText>
        </Ww>
        <Ww>
          <count>280</count>
          <WinNumber>1</WinNumber>
          <ItemText>rxBufferHeadPos,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>281</count>
          <WinNumber>1</WinNumber>
          <ItemText>idx,0x10</ItemText>
        </Ww>
        <Ww>
          <count>282</count>
          <WinNumber>1</WinNumber>
          <ItemText>Res</ItemText>
        </Ww>
        <Ww>
          <count>283</count>
          <WinNumber>1</WinNumber>
          <ItemText>Packetno</ItemText>
        </Ww>
        <Ww>
          <count>284</count>
          <WinNumber>1</WinNumber>
          <ItemText>readMem</ItemText>
        </Ww>
        <Ww>
          <count>285</count>
          <WinNumber>1</WinNumber>
          <ItemText>page,0x10</ItemText>
        </Ww>
        <Ww>
          <count>286</count>
          <WinNumber>1</WinNumber>
          <ItemText>readMem</ItemText>
        </Ww>
        <Ww>
          <count>287</count>
          <WinNumber>1</WinNumber>
          <ItemText>readMem</ItemText>
        </Ww>
        <Ww>
          <count>288</count>
          <WinNumber>1</WinNumber>
          <ItemText>readMem</ItemText>
        </Ww>
        <Ww>
          <count>289</count>
          <WinNumber>1</WinNumber>
          <ItemText>readMemm</ItemText>
        </Ww>
        <Ww>
          <count>290</count>
          <WinNumber>1</WinNumber>
          <ItemText>fromAndroid</ItemText>
        </Ww>
        <Ww>
          <count>291</count>
          <WinNumber>1</WinNumber>
          <ItemText>readConfig</ItemText>
        </Ww>
        <Ww>
          <count>292</count>
          <WinNumber>1</WinNumber>
          <ItemText>readConfig</ItemText>
        </Ww>
        <Ww>
          <count>293</count>
          <WinNumber>1</WinNumber>
          <ItemText>readConfig</ItemText>
        </Ww>
        <Ww>
          <count>294</count>
          <WinNumber>1</WinNumber>
          <ItemText>readConfig</ItemText>
        </Ww>
        <Ww>
          <count>295</count>
          <WinNumber>1</WinNumber>
          <ItemText>readConfig</ItemText>
        </Ww>
        <Ww>
          <count>296</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>297</count>
          <WinNumber>1</WinNumber>
          <ItemText>trTail,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>298</count>
          <WinNumber>1</WinNumber>
          <ItemText>trHead,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>299</count>
          <WinNumber>1</WinNumber>
          <ItemText>CDCReceiveLen,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>300</count>
          <WinNumber>1</WinNumber>
          <ItemText>buff,0x10</ItemText>
        </Ww>
        <Ww>
          <count>301</count>
          <WinNumber>1</WinNumber>
          <ItemText>idx,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>302</count>
          <WinNumber>1</WinNumber>
          <ItemText>testRead,0x10</ItemText>
        </Ww>
        <Ww>
          <count>303</count>
          <WinNumber>1</WinNumber>
          <ItemText>Buf</ItemText>
        </Ww>
        <Ww>
          <count>304</count>
          <WinNumber>1</WinNumber>
          <ItemText>len,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>305</count>
          <WinNumber>1</WinNumber>
          <ItemText>( 0x300000 - 0x200000 ) / 17</ItemText>
        </Ww>
        <Ww>
          <count>306</count>
          <WinNumber>1</WinNumber>
          <ItemText>fromAndroid,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>307</count>
          <WinNumber>1</WinNumber>
          <ItemText>readRecord</ItemText>
        </Ww>
        <Ww>
          <count>308</count>
          <WinNumber>1</WinNumber>
          <ItemText>SPI_FLASH_BUF</ItemText>
        </Ww>
        <Ww>
          <count>309</count>
          <WinNumber>1</WinNumber>
          <ItemText>memID</ItemText>
        </Ww>
        <Ww>
          <count>310</count>
          <WinNumber>1</WinNumber>
          <ItemText>SPI_FLASH_BUF</ItemText>
        </Ww>
        <Ww>
          <count>311</count>
          <WinNumber>1</WinNumber>
          <ItemText>secremain</ItemText>
        </Ww>
        <Ww>
          <count>312</count>
          <WinNumber>1</WinNumber>
          <ItemText>i,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>313</count>
          <WinNumber>1</WinNumber>
          <ItemText>byte</ItemText>
        </Ww>
        <Ww>
          <count>314</count>
          <WinNumber>1</WinNumber>
          <ItemText>i</ItemText>
        </Ww>
        <Ww>
          <count>315</count>
          <WinNumber>1</WinNumber>
          <ItemText>trHeadBuf,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>316</count>
          <WinNumber>1</WinNumber>
          <ItemText>Dst_Addr,0x10</ItemText>
        </Ww>
        <Ww>
          <count>317</count>
          <WinNumber>1</WinNumber>
          <ItemText>secpos</ItemText>
        </Ww>
        <Ww>
          <count>318</count>
          <WinNumber>1</WinNumber>
          <ItemText>secoff</ItemText>
        </Ww>
        <Ww>
          <count>319</count>
          <WinNumber>1</WinNumber>
          <ItemText>fromAndroid</ItemText>
        </Ww>
        <Ww>
          <count>320</count>
          <WinNumber>1</WinNumber>
          <ItemText>globalBuff</ItemText>
        </Ww>
        <Ww>
          <count>321</count>
          <WinNumber>1</WinNumber>
          <ItemText>uart3buf</ItemText>
        </Ww>
        <Ww>
          <count>322</count>
          <WinNumber>1</WinNumber>
          <ItemText>trHead,0x10</ItemText>
        </Ww>
        <Ww>
          <count>323</count>
          <WinNumber>1</WinNumber>
          <ItemText>trTail</ItemText>
        </Ww>
        <Ww>
          <count>324</count>
          <WinNumber>1</WinNumber>
          <ItemText>i,0x10</ItemText>
        </Ww>
        <Ww>
          <count>325</count>
          <WinNumber>1</WinNumber>
          <ItemText>trHeadBuf</ItemText>
        </Ww>
        <Ww>
          <count>326</count>
          <WinNumber>1</WinNumber>
          <ItemText>readRecord</ItemText>
        </Ww>
        <Ww>
          <count>327</count>
          <WinNumber>1</WinNumber>
          <ItemText>cntr</ItemText>
        </Ww>
        <Ww>
          <count>328</count>
          <WinNumber>1</WinNumber>
          <ItemText>parkingTransaction</ItemText>
        </Ww>
        <Ww>
          <count>329</count>
          <WinNumber>1</WinNumber>
          <ItemText>readRecord</ItemText>
        </Ww>
        <Ww>
          <count>330</count>
          <WinNumber>1</WinNumber>
          <ItemText>CDCReceiveLen,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>331</count>
          <WinNumber>1</WinNumber>
          <ItemText>buffTransaction</ItemText>
        </Ww>
        <Ww>
          <count>332</count>
          <WinNumber>1</WinNumber>
          <ItemText>sendToAndroid,0x10</ItemText>
        </Ww>
        <Ww>
          <count>333</count>
          <WinNumber>1</WinNumber>
          <ItemText>readRecord,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>334</count>
          <WinNumber>1</WinNumber>
          <ItemText>buf</ItemText>
        </Ww>
        <Ww>
          <count>335</count>
          <WinNumber>1</WinNumber>
          <ItemText>Source_Buffer[10]</ItemText>
        </Ww>
      </WatchWindow1>
      <WatchWindow2>
        <Ww>
          <count>0</count>
          <WinNumber>2</WinNumber>
          <ItemText>globalBuff</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>2</WinNumber>
          <ItemText>wiegandLen</ItemText>
        </Ww>
      </WatchWindow2>
      <MemoryWindow1>
        <Mm>
          <WinNumber>1</WinNumber>
          <SubType>0</SubType>
          <ItemText>fromAndroid</ItemText>
          <AccSizeX>0</AccSizeX>
        </Mm>
      </MemoryWindow1>
      <MemoryWindow2>
        <Mm>
          <WinNumber>2</WinNumber>
          <SubType>0</SubType>
          <ItemText>fromAndroid</ItemText>
          <AccSizeX>0</AccSizeX>
        </Mm>
      </MemoryWindow2>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>1</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <bLintAuto>0</bLintAuto>
      <bAutoGenD>0</bAutoGenD>
      <LntExFlags>0</LntExFlags>
      <pMisraName></pMisraName>
      <pszMrule></pszMrule>
      <pSingCmds></pSingCmds>
      <pMultCmds></pMultCmds>
      <pMisraNamep></pMisraNamep>
      <pszMrulep></pszMrulep>
      <pSingCmdsp></pSingCmdsp>
      <pMultCmdsp></pMultCmdsp>
      <DebugDescription>
        <Enable>0</Enable>
        <EnableFlashSeq>0</EnableFlashSeq>
        <EnableLog>0</EnableLog>
        <Protocol>2</Protocol>
        <DbgClock>10000000</DbgClock>
      </DebugDescription>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Application/MDK-ARM</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>startup_stm32f103xb.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32f103xb.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Application/User/Core</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Core/Src/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Core/Src/stm32f1xx_it.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_it.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Core/Src/stm32f1xx_hal_msp.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_msp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Application/User/USB_DEVICE/App</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../USB_DEVICE/App/usb_device.c</PathWithFileName>
      <FilenameWithoutPath>usb_device.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../USB_DEVICE/App/usbd_desc.c</PathWithFileName>
      <FilenameWithoutPath>usbd_desc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../USB_DEVICE/App/usbd_cdc_if.c</PathWithFileName>
      <FilenameWithoutPath>usbd_cdc_if.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Application/User/USB_DEVICE/Target</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../USB_DEVICE/Target/usbd_conf.c</PathWithFileName>
      <FilenameWithoutPath>usbd_conf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Drivers/STM32F1xx_HAL_Driver</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_gpio_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_gpio_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_pcd.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_pcd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_pcd_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_pcd_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_ll_usb.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_ll_usb.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_rcc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_rcc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_rcc_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_dma.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_cortex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_cortex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_pwr.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_pwr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_flash.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_flash.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_flash_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_flash_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_exti.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_exti.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_iwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_iwdg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_rtc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_rtc_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>25</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_spi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_spi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>26</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_tim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>27</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_tim_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_tim_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>28</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_uart.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_uart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>29</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_rtc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>30</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_i2c.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_i2c.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>31</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\stm32f1xx_hal_adc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_adc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>32</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\stm32f1xx_hal_adc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_adc_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Drivers/CMSIS</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>33</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Core/Src/system_stm32f1xx.c</PathWithFileName>
      <FilenameWithoutPath>system_stm32f1xx.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Middlewares/USB_Device_Library</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>34</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Middlewares/ST/STM32_USB_Device_Library/Core/Src/usbd_core.c</PathWithFileName>
      <FilenameWithoutPath>usbd_core.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>35</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Middlewares/ST/STM32_USB_Device_Library/Core/Src/usbd_ctlreq.c</PathWithFileName>
      <FilenameWithoutPath>usbd_ctlreq.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>36</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Middlewares/ST/STM32_USB_Device_Library/Core/Src/usbd_ioreq.c</PathWithFileName>
      <FilenameWithoutPath>usbd_ioreq.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
      <FileNumber>37</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/usbd_cdc.c</PathWithFileName>
      <FilenameWithoutPath>usbd_cdc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Lib</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>38</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\ee.c</PathWithFileName>
      <FilenameWithoutPath>ee.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>39</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\softuart.c</PathWithFileName>
      <FilenameWithoutPath>softuart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>40</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\stm32f1_rc522.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1_rc522.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>41</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\softuart.h</PathWithFileName>
      <FilenameWithoutPath>softuart.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>42</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\define.h</PathWithFileName>
      <FilenameWithoutPath>define.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>43</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\ee.h</PathWithFileName>
      <FilenameWithoutPath>ee.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>44</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\eeConfig.h</PathWithFileName>
      <FilenameWithoutPath>eeConfig.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>45</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\ecard.c</PathWithFileName>
      <FilenameWithoutPath>ecard.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>46</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\finger.c</PathWithFileName>
      <FilenameWithoutPath>finger.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>47</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\iso14443ab.c</PathWithFileName>
      <FilenameWithoutPath>iso14443ab.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>48</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\Config.h</PathWithFileName>
      <FilenameWithoutPath>Config.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>49</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\algorithm.c</PathWithFileName>
      <FilenameWithoutPath>algorithm.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>50</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\MAX30102.c</PathWithFileName>
      <FilenameWithoutPath>MAX30102.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>51</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\crc16.c</PathWithFileName>
      <FilenameWithoutPath>crc16.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>52</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\Dispenser.c</PathWithFileName>
      <FilenameWithoutPath>Dispenser.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>53</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\Acceptor.c</PathWithFileName>
      <FilenameWithoutPath>Acceptor.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>54</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\pn532.c</PathWithFileName>
      <FilenameWithoutPath>pn532.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>55</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\pn532_stm32f1.c</PathWithFileName>
      <FilenameWithoutPath>pn532_stm32f1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>56</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\UHF.c</PathWithFileName>
      <FilenameWithoutPath>UHF.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>57</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\Remote.c</PathWithFileName>
      <FilenameWithoutPath>Remote.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>58</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\FontIcon.c</PathWithFileName>
      <FilenameWithoutPath>FontIcon.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>59</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\LCD.c</PathWithFileName>
      <FilenameWithoutPath>LCD.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>60</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\sha-1.c</PathWithFileName>
      <FilenameWithoutPath>sha-1.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>61</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Lib\flash.c</PathWithFileName>
      <FilenameWithoutPath>flash.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
      <FileNumber>62</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Core\Src\heart_beat.c</PathWithFileName>
      <FilenameWithoutPath>heart_beat.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>::CMSIS</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>1</RteFlg>
  </Group>

</ProjectOpt>
